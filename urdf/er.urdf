Commit message: add urg_node2

File: urdf/er.urdf (robot description, URDF)
Before this commit: robot nav_omni4, 3 links, 2 joints
Links:
- removed link lidar_link1
- added link lidar_link; visual cylinder length=0.01 radius=0.006
Joints:
- joint lidar_joint: child lidar_link1 -> lidar_link
